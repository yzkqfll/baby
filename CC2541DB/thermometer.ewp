# IAR project thermometer.ewp, settings and files
configuration CC2541DK-MINI Keyfob Slave (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541.i51
  ICC8051.CCDefines: INT_HEAP_LEN=2900; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\Profiles\Roles; ..\..\Profiles\Thermometer; ..\..\Profiles\DevInfo; ..\..\Profiles\Batt
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541 Slave (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3008; CC2541; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_UART=TRUE; HAL_KEY=FALSE; HAL_ADC=FALSE; DMA_PM=FALSE; XOSC32K_INSTALLED=FALSE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\Profiles\Roles; ..\..\Profiles\DevInfo; ..\..\Profiles\Batt; ..\..\Profiles\HidDev; ..\Source
  group APP
    ../Source/: hal_i2c.c hal_i2c.h OnBoard.c OnBoard.h OSAL_thermometer.c ther_adc.c ther_adc.h ther_ble.c ther_ble.h ther_button.c ther_button.h ther_buzzer.c ther_buzzer.h ther_comm.c ther_comm.h ther_oled_9639.c ther_oled_9639.h ther_profile.c ther_profile.h ther_temp.c ther_temp.h ther_temp_cal.c ther_temp_cal.h ther_uart.c ther_uart.h ther_uart_comm.c ther_uart_comm.h thermometer.c thermometer.h thermometer_Main.c timeapp.h timeapp_clock.c timeapp_config.c timeapp_discovery.c timeapp_ind.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi_spi.c npi_uart.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Batt/: battservice.c battservice.h
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
